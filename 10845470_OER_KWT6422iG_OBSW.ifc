Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 58286e63-242f-4073-a51e-da749473ca45, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-14T23:29:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10845470_OER_KWT6422iG_OBSW:36642220_OER_10845470_KWT6422iG_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_Alusilver, Default New Material, Poche, z_Miele_Design_OBSW, z_Miele_Design_Glass, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 557 mm; Height: 871 mm; Depth: 560 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36642220_OER_10845470_KWT6422iG_OBSW; sets with these values: 2

# IfcDistributionPort, Port_361813_1
Description: Flow; FlowDirection: SOURCEANDSINK
